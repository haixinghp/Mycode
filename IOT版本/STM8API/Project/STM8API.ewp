# IAR project STM8API.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x240
  General.GenHeapSize: 0x110
  ICCSTM8.CCDefines: STM8L15X_HD; BUILD_PROJECT=BOOT_HD
  ICCSTM8.CCIncludePath2: ..\API; ..\App; ..\BSP\CESHI; ..\BSP\GPIO; ..\BSP\IAP; ..\BSP\iap_updata; ..\BSP\LED; ..\BSP\MCU; ..\BSP\HARD_SPI; ..\BSP\W25QXX; ..\BSP\USART; ..\BSP\24CXX; ..\BSP\WatchDog; ..\BSP\FLASH; ..\Protocol; ..\Protocol\DownLoad; ..\Protocol\PostProDa; ..\Protocol\WCDMA; ..\Protocol_send; ..\qwl_net; ..\qwl_net\cdma; ..\qwl_net\NBLOT; ..\UserLib\BasicFunc; ..\UserLib\data; ..\UserLib\LowPrecisionTime; ..\SmartAlarmer_Sys\Delay; ..\SmartAlarmer_Sys\Lowpower; ..\SmartAlarmer_Sys\Main; ..\SmartAlarmer_Sys\Ringbuf; ..\SmartAlarmer_Sys\Rtc; ..\SmartAlarmer_UserLib\EEprom; ..\SmartAlarmer_UserLib\SA_Protocol; ..\SmartAlarmer_UserLib\Spi; ..\SmartAlarmer_UserLib\Timer; ..\SmartAlarmer_UserLib\Uart; ..\SmartAlarmer_UserLib\Gpio; ..\SmartAlarmer_UserLib\Radar_And_Ultrasonic; ..\\FwLib\inc; ..\BSP\RTC_SD3078; ..\BSP\ADC; ..\SmartAlarmer_Sys\Storage; ..\App\Pressure; ..\App\NewInactAngle; ..\SmartAlarmer_Sys\Cover; ..\qwl_net\G510
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8API301.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\Project\lnkstm8l052r8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group ABOUTIAP/API
    ../API/: api.c api.h
  group ABOUTIAP/APP
    ../App/: config.h globe.h main.c moduleSelect.h Public.c Public.h stm8l15x_conf.h stm8l15x_it.c
    ../BSP/FLASH/: Flash.c
  group ABOUTIAP/BSP
    ../BSP/ADC/: ADC.c
    ../SmartAlarmer_Sys/Rtc/: c_IIC_Soft.c
    ../BSP/GPIO/: GpioMap.c GpioMap.h
    ../BSP/HARD_SPI/: hardwareSTM8L_SPI.c
    ../BSP/IAP/: IAP.c
    ../BSP/iap_updata/: iap_updata.c
    ../BSP/24CXX/: iic_eep.c
    ../BSP/LED/: LED.c
    ../BSP/RTC_SD3078/: RTC_SD3078.c
    ../BSP/USART/: USART.c
    ../BSP/W25QXX/: W25QXX.c
    ../BSP/Watchdog/: watchdog.c
  group ABOUTIAP/data
    ../UserLib/data/: data.c data.h
  group ABOUTIAP/DownLoad
    ../Protocol/DownLoad/: DownLoad.c DownLoad_Pro.c
  group ABOUTIAP/PostProDa
    ../Protocol/PostProDa/: PostProDa.c Uploading_Pro.c
  group ABOUTIAP/Protocol
    ../Protocol/: Protocol.c Protocol_wcdma.c ProtocolRecCallBack.c
    ../Protocol_send/: Protocol_send.c
  group ABOUTIAP/qwl_net
    ../qwl_net/cdma/: cdma.c
    ../qwl_net/G510/: g510.c
    ../qwl_net/NBLOT/: nblot.c
    ../qwl_net/: qwl_net.c
  group ABOUTIAP/Timer
    ../UserLib/LowPrecisionTime/: LowPrcisionTime.c
  group ABOUTIAP/UserLib
    ../UserLib/BasicFunc/: BasicFunc.c
  group doc
    ../doc/: WCDMA_CDMAShortMsgCmd.txt 井盖(EEPROM) 硬件V105.txt 井盖(EEPROM).txt 井盖(FLASH).txt 智能水压固件V3升级记录.txt 智能闷盖固件V3升级记录.txt 测试代码.txt
  group FwLib
    ../FwLib/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim4.c stm8l15x_usart.c
  group SA_sys/Cover
    ../SmartAlarmer_Sys/Cover/: Cover.c
  group SA_sys/Delay
    ../SmartAlarmer_Sys/Delay/: Delay.c
  group SA_sys/Lowpower
    ../SmartAlarmer_Sys/Lowpower/: lowpower.c
  group SA_sys/Main
    ../SmartAlarmer_Sys/Main/: sys.c
  group SA_sys/NewInactAngle
    ../App/NewInactAngle/: NewInactAngle.c
  group SA_sys/Other
    ../App/: xiaofang.c
  group SA_sys/Pressure
    ../App/Pressure/: Pressure.c PressureSys.c
  group SA_sys/Rtc
    ../App/Pressure/: Interval.c
    ../SmartAlarmer_Sys/Rtc/: rtc.c tick.c TimeOfAlarm.c TimeOfAlarmPressure.c
  group SA_sys/Storage
    ../SmartAlarmer_Sys/Storage/: FLASH_Queue.c
  group SA_UserLib/EEprom
    ../SmartAlarmer_UserLib/EEprom/: EEprom.c
  group SA_UserLib/Radar_And_Ultrasonic
    ../SmartAlarmer_UserLib/Radar_And_Ultrasonic/: Radar_And_Ultrasonic.c
  group SA_UserLib/SA_Protocol
    ../SmartAlarmer_UserLib/SA_Protocol/: SA_Protocol.c
  group SA_UserLib/Spi
    ../SmartAlarmer_UserLib/Gpio/: exitinterrupt.c
    ../SmartAlarmer_UserLib/Spi/: lowpower_spi.c
  group SA_UserLib/Timer
    ../SmartAlarmer_UserLib/Timer/: Timer.c
  group SA_UserLib/Uart
    ../SmartAlarmer_UserLib/Uart/: lowpower_uart.c
